# Keil uVision project PrjSdkRam.uvproj, settings and files
target PrjSdkRam (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SdkFw +hex
  AfterMake: bin.bat
  c flags: Optim=4
  c define: USE_CORTEX_M3
  c misc: --littleend --loose_implicit_cast
  c include: ..\..\Source\Include;..\..\Source\Ports\Cortex-M3;..\..\Source\uCOS-II;..\..\Source\BSP;..\..\Source\WiFi\include;..\..\Source\LwIP\src\include;..\..\Source\LwIP\port\include;..\..\Source\LwIP\src\include\ipv4;..\..\Source\LwIP\src\include\ipv6;..\..\Source\LwIP\src\include\lwip;..\..\Source\LwIP\src\include\netif;..\..\Source\LwIP\port\include\netif;..\..\Source\App\NuAgent\Wifi;..\..\Source\App\NuAgent\System;..\..\Source\App\NuAgent\Lib;..\..\Source\App\NuAgent\Include;..\..\Source\App\NuAgent\Device;..\..\Source\App\NuAgent\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\scatter_loader.scat
  group BSP
    ../../Source/BSP/: nl6621_BspDemo.c nl6621_BspDemo.h bsp.c nl6621_gpio.c nl6621_exti.c nl6621_usart.c nl6621_timer.c nl6621_wdg.c nl6621_qspi.c nl6621_spi.c nl6621_i2c.c nl6621_i2s.c nl6621_sdio.c nl6621_dma.c printf.c mpu.c nl6621_nvic.c cortexM3_it.c cortexm3_macro.s
  group BOOT
    ../../Source/BOOT/: CortexM3_startup.s
  group uCOS
    ../../Source/uCOS-II/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_tmr.c os_task.c os_time.c
  group Ports
    ../../Source/Ports/Cortex-M3/: cpu_a.asm os_cpu_c.c os_cpu_a.asm os_dmem.c
  group LWIP
    ../../Source/LwIP/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../Source/LwIP/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../Source/LwIP/src/core/: udp.c def.c dhcp.c dns.c lwip_init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c
    ../../Source/LwIP/src/netif/: etharp.c
    ../../Source/LwIP/port/: sys_arch.c lwIP.c
  group Sys
    ../../Source/Sys/: main.c param.c rom_hook_tbl.c sys_mgmt.c util.c
  group Include
    ../../Source/Include/: app_cfg.h global.h includes.h param.h rom_hook_tbl.h task_util.h types_def.h util.h
  group DhcpServer
    ../../Source/App/DhcpServer/: dhcp_server.c
  group DnsServer
    ../../Source/App/DnsServer/: dns_server.c
  group Lib
    ../../Source/Lib/: wcore.lib libairkiss_log.lib libairkiss.lib libairkiss_aes.lib libairkiss_aes_log.lib
  group NuAgent
    ../../Source/App/NuAgent/: AgentEntrance.c
    ../../Source/App/NuAgent/Wifi/: wifi_conn.c sniffer_config.c wifi_opt.c
    ../../Source/App/NuAgent/System/: agent_core.c network_adapter.c nuagent_uart.c nuagent_drv.c
    ../../Source/App/NuAgent/Lib/: ntp_client.c ring_buffer.c str_lib.c cJSON.c
    ../../Source/App/NuAgent/Device/: simu_uart.c simu_iic.c
    ../../Source/App/NuAgent/Sample/: TestMain.c
    ../../Source/App/NuAgent/User/: log.c
  group User
    ../../Source/App/NuAgent/User/: cloud.c lan.c
